<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>200e3</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>Num Channels</value></param>
<param><key>value</key><value>128</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>n</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>label</key><value>Packet Length</value></param>
<param><key>value</key><value>50</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>l</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>Cyclic Prefix Length</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>c</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_amp</value></param>
<param><key>label</key><value>Transmit Amplitude</value></param>
<param><key>value</key><value>0.125</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>Transmit Gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>label</key><value>Transmit Frequency</value></param>
<param><key>value</key><value>2.5e9</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>addr</value></param>
<param><key>label</key><value>Address</value></param>
<param><key>value</key><value>type=b200</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>len_tag_key</key><value>len_tag_key</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>len_tag_key</key><value>len_tag_key</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>tx_amp</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>packet_len_key</key><value>len_tag_key</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>50000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>cp_len</key><value>cp_len</value></param>
<param><key>packet_len_key</key><value>len_tag_key</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>payload_mod</key><value>"QPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>rrate</key><value>10</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>rrate</key><value>5</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-40000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_channelizer2_tx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_ofdm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
