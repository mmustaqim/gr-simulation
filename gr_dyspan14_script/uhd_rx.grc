<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>wintype</key><value>firdes.WIN_FLATTOP</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>wintype</key><value>firdes.WIN_FLATTOP</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>rx_gain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>73</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>rx_freq</value></param>
<param><key>start</key><value>900</value></param>
<param><key>stop</key><value>2200</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Receive Frequency (MHz)</value></param>
<param><key>value</key><value>915</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>Receive Gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq*1e6</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
