<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/mnm/Desktop/fm.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>25e3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_cut_off</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>25e3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>freq_cut_off</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>window.flattop</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb,2</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['tab1', 'tab2', 'tab3']</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>fc</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>fc</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>freq_cut_off</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>low_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
